# SPDX-License-Identifier: MIT
# Copyright 2023 iris-GmbH infrared & intelligent sensors

OSSELOT_NAME ?= "libexpat"
OSSELOT_VERSION ?= "R_${@d.getVar('PV').replace('.', '_')}"
