# SPDX-License-Identifier: MIT
# Copyright 2023 iris-GmbH infrared & intelligent sensors

OSSELOT_VERSION ?= "FILE${@d.getVar('PV').replace('.', '_')}"
