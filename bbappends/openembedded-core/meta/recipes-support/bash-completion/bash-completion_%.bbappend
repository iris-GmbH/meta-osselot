# SPDX-License-Identifier: MIT
# Copyright 2023 iris-GmbH infrared & intelligent sensors

# For some reason, bash-completion S dir is not set in original recipe
S ?= "${WORKDIR}/${BPN}-${PV}"
