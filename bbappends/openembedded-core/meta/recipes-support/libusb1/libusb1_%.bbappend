# SPDX-License-Identifier: MIT
# Copyright 2024 Hirschmann Automation and Control GmbH

OSSELOT_NAME ?= "libusb"
