# SPDX-License-Identifier: MIT
# Copyright 2024 iris-GmbH infrared & intelligent sensors

## Define equivalence between unpatched and patched source code files
## Unpatched hashes taken from gmp/6.2.1
# configure.ac
OSSELOT_HASH_EQUIVALENCE += "536ea84e25b8c948f7bb9b12b105fd71:74c8802a00118e1faba6468fec41389a"
# Makefile.am
OSSELOT_HASH_EQUIVALENCE += "75c5d336c9bfee252cfd92ea2f9745d0:7759224d52af035030c10984228cf4f2"
# mpz/inp_raw.c
OSSELOT_HASH_EQUIVALENCE += "8d98075bbd0bda0888ad55faad3d8026:aab8a63c68e662dacdd22cd5fb41650e"
