# SPDX-License-Identifier: MIT
# Copyright 2024 iris-GmbH infrared & intelligent sensors

OSSELOT_NAME ?= "Python"
