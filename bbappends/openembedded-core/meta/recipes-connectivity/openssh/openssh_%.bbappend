# SPDX-License-Identifier: MIT
# Copyright 2024 Hirschamnn Automation and Control GmbH

OSSELOT_NAME ?= "openSSH"
