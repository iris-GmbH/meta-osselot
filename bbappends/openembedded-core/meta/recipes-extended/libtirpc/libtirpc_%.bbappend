# SPDX-License-Identifier: MIT
# Copyright 2024 iris-GmbH infrared & intelligent sensors

## Define equivalence between unpatched and patched source code files
## Unpatched hashes taken from libtirpc/1.3.2
# src/svc.c
OSSELOT_HASH_EQUIVALENCE += "9c18c38fea47734630f8db50f500c756:72f49dd6a1e30607832487e314a5d088"
# src/svc_vc.c
OSSELOT_HASH_EQUIVALENCE += "cbea8752924a225b13ccddf7d6071e44:0510e29226eb3bb25cb1749133166135"
