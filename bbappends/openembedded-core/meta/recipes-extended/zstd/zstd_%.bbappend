# SPDX-License-Identifier: MIT
# Copyright 2024 iris-GmbH infrared & intelligent sensors

OSSELOT_IGNORE_SOURCE_GLOBS += "tests/gzip/hufts-segv.gz"
