# SPDX-License-Identifier: MIT
# Copyright 2023 iris-GmbH infrared & intelligent sensors

OSSELOT_NAME ?= "procps-ng"
OSSELOT_VERSION ?= "v${PV}"
